# Keil uVision project drl51822project.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.7.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: DTQ_RP552TX_ZKXL0200_V0204 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NRF_LOG_USES_RTT=1 BOARD_PCA10028 NRF_LOG_USES_UART=1 NRF51 SWI_DISABLE0 NRF51
  c misc: --c99
  c include: ..\components\drivers_nrf\hal;..\components\toolchain\CMSIS\Include;..\components\drivers_nrf\delay;..\components\properitary_rf\esb;..\components\drivers_nrf\nrf_soc_nosd;..\components\libraries\util;..\components\toolchain;..\components\libraries\timer;..\components\libraries\scheduler;..\components\drivers_nrf\spi_slave;..\components\drivers_nrf\common;..\components\drivers_nrf\config;..\components\drivers_nrf\wdt
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group user
    ../user/: main.c my_uart.c my_timer.c my_radio.c my_spi.c ringbuf2.c se2431l.c ringbuf_nrf.c watchdog.c flash.c
  group lib
    ../user/: simple_uart.c
    ../components/drivers_nrf/delay/: nrf_delay.c
    ../components/properitary_rf/esb/: nrf_esb.c
    ../components/libraries/timer/: app_timer.c
    ../components/libraries/util/: app_error.c nrf_assert.c app_error_weak.c app_util_platform.c
    ../components/drivers_nrf/spi_slave/: nrf_drv_spis.c
    ../components/drivers_nrf/common/: nrf_drv_common.c
    ../components/drivers_nrf/wdt/: nrf_drv_wdt.c
  group device
    ../components/toolchain/: system_nrf51.c
    ../components/toolchain/arm/: arm_startup_nrf51.s
